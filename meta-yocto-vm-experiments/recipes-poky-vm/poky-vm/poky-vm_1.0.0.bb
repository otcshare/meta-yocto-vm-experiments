SUMMARY = "An image containing the build system itself"

require poky-vm.inc

PROVIDES_${PN} = "poky-vm"


